# IAR project cm7_0.ewp, settings and files
configuration rev_a (ARM, debug)
  General.OGChipSelectEditMenu: CYT4DN_M7 Infineon CYT4DN_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: tviic2d6m; CYT4DNDBHS; CY_USE_PSVP=0; CY_MCU_rev_a; CY_CORE_CM7_0; __ICACHE_PRESENT=1; __DCACHE_PRESENT=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\..\tviic2d6m\hdr\rev_a; ..\..\..\..\..\tviic2d6m\hdr\rev_a\ip; ..\..\..\..\..\tviic2d6m\hdr\rev_a\mcureg; ..\..\..\..\..\tviic2d6m\src; ..\..\..\..\..\tviic2d6m\src\drivers; ..\..\..\..\..\tviic2d6m\src\interrupts\rev_a; ..\..\..\..\..\tviic2d6m\src\mw; ..\..\..\..\..\tviic2d6m\src\system\rev_a
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cm7_0.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: _CORE_$PROJ_FNAME$_=0; _LINK_$LINK_LOCATION$_=0
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviic2d.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\tviic2d6m\src\drivers\crypto\libs\libcrypto_client_cm7_0_iar.a; ..\libmw\rev_a\cm7\libmw.a; ..\libsdl\rev_a\cm7\libsdl.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration rev_b (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviic2d6m; CYT4DNJBRS; CY_USE_PSVP=0; CY_MCU_rev_b; CY_CORE_CM7_0; __ICACHE_PRESENT=1; __DCACHE_PRESENT=1
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\hdr\rev_b; ..\..\..\..\hdr\rev_b\ip; ..\..\..\..\hdr\rev_b\mcureg; ..\..\..\..\src; ..\..\..\..\src\drivers; ..\..\..\..\src\interrupts\rev_b; ..\..\..\..\src\mw; ..\..\..\..\src\system\rev_b
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviic2d_rev_b.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\src\drivers\crypto\libs\libcrypto_client_cm7_0_iar.a; ..\libmw\rev_b\cm7\libmw.a; ..\libsdl\rev_b\cm7\libsdl.a
  group hdr
    ../../../../../common/hdr/: cy_project.h
  group hdr/cmsis/include
    ../../../../../common/hdr/cmsis/include/: cmsis_compiler.h core_cm0plus.h
  group hdr/rev_a
    ../../../../hdr/rev_a/: bb_bsp_tviic2d6m.h cy_device_headers.h cyt4dn_config.h
  group hdr/rev_a/ip
    ../../../../hdr/rev_a/ip/: cyip_backup_v3.h cyip_canfd.h cyip_coredefines.h cyip_cpuss.h cyip_crypto.h cyip_cxpi.h cyip_dac.h cyip_dmac.h cyip_dw.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_eth.h cyip_evtgen.h cyip_fault.h cyip_flashc.h cyip_gpio_v4.h cyip_headers.h cyip_hsiom_v4.h cyip_i2s.h cyip_ipc.h cyip_lin.h cyip_mixer.h cyip_pass.h cyip_peri_ms_v3.h cyip_peri_pclk_v3.h cyip_peri_v3.h cyip_prot.h cyip_pwm.h cyip_scb_v2.h cyip_sflash_v2.h cyip_sg.h cyip_smartio_v4.h cyip_smif_v3.h cyip_srss_v3.h cyip_tcpwm_v2.h cyip_tdm.h cyip_videoss.h
  group hdr/rev_b
    ../../../../hdr/rev_b/: bb_bsp_tviic2d6m.h cy_device_headers.h cyt4dn_config.h
  group hdr/rev_b/ip
    ../../../../hdr/rev_b/ip/: cyip_axi_dmac.h cyip_backup_v3.h cyip_canfd.h cyip_coredefines.h cyip_cpuss.h cyip_crypto.h cyip_cxpi.h cyip_dac.h cyip_dmac.h cyip_dw.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_eth_v2.h cyip_evtgen.h cyip_fault.h cyip_flashc.h cyip_gpio_v5.h cyip_headers.h cyip_hsiom_v5.h cyip_ipc.h cyip_jpegdec.h cyip_lin.h cyip_mixer.h cyip_pass.h cyip_pd.h cyip_peri_ms_v3.h cyip_peri_pclk_v3.h cyip_peri_v3.h cyip_prot.h cyip_pwm.h cyip_scb_v2.h cyip_sflash_v2.h cyip_sg.h cyip_smartio_v5.h cyip_smif_v4.h cyip_srss_v3.h cyip_tcpwm_v2.h cyip_tdm.h cyip_videoss.h
  group src
    ../../../../src/: main_cm7_0.c
  group src/interrupts/rev_a
    ../../../../src/interrupts/rev_a/: cy_interrupt_map.c cy_interrupt_map_cm7_0.h
  group src/interrupts/rev_b
    ../../../../src/interrupts/rev_b/: cy_interrupt_map.c cy_interrupt_map_cm7_0.h
  group src/startup
    ../../../../../common/src/startup/: startup.c startup_customize.h
    ../../../../../common/src/startup/iar/: startup_cm7.s
  group src/system/rev_a
    ../../../../src/system/rev_a/: system_cyt4dn.h system_tviic2d6m_cm7.c
  group src/system/rev_b
    ../../../../src/system/rev_b/: system_cyt4dn.h system_tviic2d6m_cm7.c
