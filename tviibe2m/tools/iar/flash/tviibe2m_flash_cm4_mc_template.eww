<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\cm4_mc\cm4.ewp</path>
    </project>
    <batchBuild />
</workspace>
